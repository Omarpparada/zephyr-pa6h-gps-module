## zephyr/dts/bindings/sensor/adafruit,pa6h.yaml
```yaml
description: "PA6H GPS module (Adafruit breakout)"
compatible: "adafruit,pa6h"
include: [uart-device.yaml]
```
